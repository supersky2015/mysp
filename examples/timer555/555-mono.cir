** 555_uc253557a33 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Administrator
* Thu, May 14, 2015 16:59:13
*

vV1 4 0 ac 1 0
+   distof1 0 0
+   distof2 0 0
+   pulse(5 0 0 1e-009 1e-009 0.002 0.02)

VCCVCC  VCC 0 dc 5

cC2 1 0 1e-005

cC1 2 0 1e-008

rR1 VCC 1 1200

xU1 0 4 3 VCC 2 1 1 VCC TIMER_RATEDU1
.subckt TIMER_RATEDU1 1 2 3 4 5 6 7 8
Rvsns 8 1 1e15
Rcsns 3a 3 0
rn1 8 5 5k
rn2 5 51 5k
rn3 51 1 5k
aop1 %vd(5 6) 56 op
aop2 %vd(2 51) 52 op
.model op limit (gain= 3000,
+ out_upper_limit=5,
+ out_lower_limit=-5,
+ limit_range=1 fraction=true)
aadc1 [56 52] [r s] ADC1
.MODEL ADC1 adc_bridge (in_low= 2.8  in_high = 3.5 rise_delay= 1e-12 fall_delay= 1e-12)
anand1 [r Q2] Q1  nand1
anand2 [s Q1] Q2  nand1
.model nand1 d_nand(rise_delay=1n)
adac1 [q1 q2] [66 62] DAC1
rad3 66 1 1
rad4 62 1 1
aadc4 [4] [40] ADC1
ainv2 40 41 inv1
adlatch q1 2u 41 3d Qb Qc dlt
.model dlt d_dlatch(rise_delay=1e-12)
apu1 2u pullup1
.model pullup1 d_pullup(load=10e-12)
apd1 3d pulldown1
.model pulldown1 d_pulldown(load=10e-12)
ainv1 Qb 31 inv1
.model inv1 d_inverter(rise_delay=1e-12)
adac72 [Qb] [72] DAC1
adac31 [31] [32] DAC1
r30 32 1 1G
b1 99 1 v=(v(32)*v(8)/5)
Rb1 99 98 1e6
Rb2 98 1 1e6
b2 3a 1 v=v(98)*2
r3 3a 1 1G
.MODEL DAC1 dac_bridge  (out_low= 0.0 out_high= 5.0 out_undef=0.5)
rad5 72 1 1meg
mdis 7 72 1 1 mdis
.MODEL mdis nmos (VTO=1.29 PHI=0.4 LAMBDA=5 KP=4.3m LD=12.8u GAMMA =3)
.ends

.control
tran 100u 100m uic
plot v(4) v(1) v(3)
*alter rR1=1000
*tran 100u 100m uic
*plot v(4) v(1) v(3)
.endc
